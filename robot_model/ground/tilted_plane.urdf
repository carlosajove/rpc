Commit message: first commit

File: robot_model/ground/tilted_plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link base_link: geometry collision plane normal=0 0 1; visual mesh filename=plane.obj scale=0.5 0.5 0.5
